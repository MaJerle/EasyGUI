# Keil uVision project gui_dev_rtos.uvprojx, settings and files
target STM32F7_DISCOVERY (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F746xx,USE_HAL_DRIVER,ARM_MATH_CM7,__FPU_PRESENT=1,STM32F7XX,STM32F7_DISCOVERY,HSE_VALUE=25000000,RCC_OSCILLATORTYPE=RCC_OSCILLATORTYPE_HSE,RCC_PLLSOURCE=RCC_PLLSOURCE_HSE,RCC_PLLM=25,RCC_PLLN=400,RCC_PLLP=2,RCC_PLLQ=7,RCC_PLLR=6
  c include: .\User;.\TM;..\00-STM32_LIBRARIES;..\00-HAL_DRIVERS\STM32F7xx_HAL_Driver\Inc;..\00-HAL_DRIVERS\CMSIS\Device\ST\STM32F7xx\Include;..\00-HAL_DRIVERS\CMSIS\Include;..\00-STM32_LIBRARIES\FreeRTOS\include;..\00-STM32_LIBRARIES\FreeRTOS\CMSIS_RTOS;..\00-STM32_LIBRARIES\FreeRTOS\portable\RVDS\ARM_CM4F;..\00-GUI_LIBRARY;..\00-GUI_LIBRARY\input;..\00-GUI_LIBRARY\pt;..\00-GUI_LIBRARY\widgets;..\00-GUI_LIBRARY\utils;..\00-STM32_LIBRARIES\fatfs;..\00-STM32_LIBRARIES\fatfs\drivers;..\00-STM32_LIBRARIES\fatfs\option
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group STM32F7_HAL_Drivers
    ../../libs/st_hal/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dsi.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_spi.c stm32f7xx_hal_uart.c stm32f7xx_ll_fmc.c
  group TM
    ../../libs/: tm_stm32_buffer.c tm_stm32_delay.c tm_stm32_disco.c tm_stm32_dma.c tm_stm32_general.c tm_stm32_gpio.c tm_stm32_i2c.c tm_stm32_rcc.c tm_stm32_usart.c tm_stm32_usart_dma.c
  group User
    ../src/: main.c stm32fxxx_it.c
  group FreeRTOS
    ../../libs/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../libs/FreeRTOS/portable/RVDS/ARM_CM4F/: port_cm4.c
    ../../libs/FreeRTOS/portable/MemMang/: heap_4.c
    ../../libs/FreeRTOS/CMSIS_RTOS/: cmsis_os.c cpu_utils.c
  group LCD
    ../../libs/: tm_stm32_exti.c tm_stm32_sdram.c tm_stm32_touch.c
  group LCD_STM32F7_DISCOVERY
    ../00-STM32_LIBRARIES/: tm_stm32_touch_ft5336.c
    ./User/: lcd_stm32f7_discovery.c
  group LCD_STM32F769_DISCOVERY
    ../src/: otm8009a.c lcd_stm32f769_discovery.c
    ../../libs/: tm_stm32_touch_ft6206.c
  group GUI
    ../../src/gui/: gui.c gui_draw.c gui_lcd.c
  group GUI SYS LL
    ../../src/system/: gui_system_cmsis_os.c gui_ll_stm32_dma2d.c
  group GUI WIDGETS
    ../../src/widget/: gui_button.c gui_checkbox.c gui_container.c gui_dialog.c gui_dropdown.c gui_edittext.c gui_graph.c gui_image.c gui_led.c gui_list_container.c gui_listbox.c gui_listview.c gui_progbar.c gui_radio.c gui_slider.c gui_widget.c gui_window.c gui_textview.c
  group GUI INPUT
    ../../src/gui/: gui_input.c gui_keyboard.c
  group GUI UTILS
    ../../src/gui/: gui_buffer.c gui_linkedlist.c gui_math.c gui_mem.c gui_string.c gui_timer.c gui_translate.c
  group GUI FONTS
    ../../src/fonts/: Arial_Bold_AA.c Arial_Narrow_Italic.c Arial_Narrow_Italic_AA.c Calibri_Bold.c Comic_Sans_MS_Regular.c FontAwesome_Regular.c
target STM32F769_DISCOVERY (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x200000) IROM2(0x00200000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32F769xx,USE_HAL_DRIVER,ARM_MATH_CM7,__FPU_PRESENT=1,STM32F7XX,STM32F769_DISCOVERY,HSE_VALUE=25000000,RCC_OSCILLATORTYPE=RCC_OSCILLATORTYPE_HSE,RCC_PLLSOURCE=RCC_PLLSOURCE_HSE,RCC_PLLM=25,RCC_PLLN=400,RCC_PLLP=2,RCC_PLLQ=7,RCC_PLLR=6
  c include: ..\include;..\..\src\include;..\..\libs;..\..\libs\st_hal\CMSIS\Include;..\..\libs\st_hal\CMSIS\Device\ST\STM32F7xx\Include;..\..\libs\st_hal\STM32F7xx_HAL_Driver\Inc;..\..\libs\FreeRTOS\include;..\..\libs\FreeRTOS\CMSIS_RTOS;..\..\libs\FreeRTOS\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
software components: CMSIS:CORE 5.0.2, Device:Startup 1.2.0
